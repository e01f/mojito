*SPICE netlist, auto-generated by createFullNetlist()

*------Env and Rnd Variables---------

.param pRload = 1.000e+07
.param pVcc = 1.000e+01
.param pVee = -1.000e+01

*------Design---------
R0 nVin n_auto_1  R=7500
R1a n_auto_1 gnd  R=6200
C1b n_auto_1 gnd  C=330e-12
R2 n_auto_1 nVcc  R=2.7e6

Rwire4 n_auto_1 n_auto_2  R=0

R5 gnd n_auto_3  R=4120

Rwire8 n_auto_2 n_auto_4  R=0
Rwire9 n_auto_3 n_auto_5  R=0
Rwire10 n_auto_4 n_auto_7  R=0
Rwire11 n_auto_5 n_auto_6  R=0

X12 n_auto_6 n_auto_7 nVcc nVee n_auto_8 LF411C

Rwire14 n_auto_8 nout  R=0
R15a n_auto_5 nout  R=1e6
C15b n_auto_5 nout  C=5e-12
R17 nout nVcc  R=4700

*------Test Fixture---------

Rload   nout    gnd pRload

* biasing circuitry
Vcc         nVcc        gnd         DC=pVcc
Vee         nVee        gnd         DC=pVee
Vin         nVindc      gnd         DC=-0.5
VinNoDc     nVinNodc    nVindc      PULSE(0 0.5 0.001)
Vinac       nVin        nVinNodc    SIN(0 5 1000 0.001)

* this measures the amount of feedback biasing there is

* simulation statements
.op
* ac decadic 50ppDecade 1Hz to 100kHz
*.ac dec 50  1   100000
.TRAN 0.000003 0.003

*.probe ac V(nout)
*.probe ac V(nVin)
*.probe ac V(*)

* time-domain measurements
.measure TRAN voutdc        AVG  V(nout) TO=0.001
.measure TRAN voutav1       AVG  V(nout) FROM=0.001  TO=0.0015
.measure TRAN voutav2       AVG  V(nout) FROM=0.0015 TO=0.002
.measure TRAN voutav3       AVG  V(nout) FROM=0.002  TO=0.0025
.measure TRAN voutav4       AVG  V(nout) FROM=0.0025 TO=0.003
.measure TRAN voutpp1        PP  V(nout) FROM=0.0011 TO=0.0014
.measure TRAN voutpp2        PP  V(nout) FROM=0.0016 TO=0.0019
.measure TRAN voutpp3        PP  V(nout) FROM=0.0021 TO=0.0024
.measure TRAN voutpp4        PP  V(nout) FROM=0.0026 TO=0.0029
.measure TRAN toutzc1       FIND 'time'  WHEN V(nout)=0 TD=0.001
.measure TRAN toutzc2       FIND 'time'  WHEN V(nout)=0 TD=0.0015
.measure TRAN toutzc3       FIND 'time'  WHEN V(nout)=0 TD=0.002
.measure TRAN toutzc4       FIND 'time'  WHEN V(nout)=0 TD=0.0025
.measure tran maxpwr        MAX  power
.measure tran avgpwr        AVG  power

*------Simulator Options---------

.include C:/BA/mojito/problems/zcd/simulator_options.inc

*------Models---------

.include C:/BA/mojito/problems/zcd/models.inc

.end
